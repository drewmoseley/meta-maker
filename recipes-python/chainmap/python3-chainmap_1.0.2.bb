inherit pypi setuptools3
require python-chainmap.inc

