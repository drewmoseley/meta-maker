SUMMARY = "A collection of cache libraries in the same API interface. Extracted from werkzeug"
HOMEPAGE = "https://github.com/pallets/cachelib"
LICENSE = "BSD"
SECTION = "devel/python"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a32a7594742a04098377c0c777ec1af7"

SRC_URI[md5sum] = "fb261e459dfea074cd20440e2674e102"
SRC_URI[sha256sum] = "47e95a67d68c729cbad63285a790a06f0e0d27d71624c6e44c1ec3456bb4476f"

inherit setuptools3 pypi

